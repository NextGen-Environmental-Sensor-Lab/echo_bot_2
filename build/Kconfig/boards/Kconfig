## build/Kconfig/boards/Kconfig
```kconfig
# Load Zephyr board Kconfig descriptions.
osource "/opt/nordic/ncs/v2.8.0/zephyr/boards/actinius/icarus/Kconfig"
```
